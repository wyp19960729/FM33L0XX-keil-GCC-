# Keil uVision project FM33L0XX_Tester.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33L02X FMSH
  pack: Keil.FM33L0XX_DFP.0.1.4
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33L0XX_Tester +hex
  group UserCode
    ../UserCode/: main.c user_init.c
    ./RTE/Device/FM33L01X/: system_FM33L0XX.c
  group stdperiph_driver
    ../Drivers/: fm33l0xx_adc.c fm33l0xx_aes.c fm33l0xx_atim.c fm33l0xx_beeper.c fm33l0xx_bstim.c fm33l0xx_crc.c fm33l0xx_dbg.c fm33l0xx_dma.c fm33l0xx_flash.c fm33l0xx_gpio.c fm33l0xx_gptim.c fm33l0xx_i2c.c fm33l0xx_iwdt.c fm33l0xx_lcd.c fm33l0xx_lptim.c fm33l0xx_lpuart.c fm33l0xx_opa.c fm33l0xx_pmu.c fm33l0xx_rcc.c fm33l0xx_rng.c fm33l0xx_rtc.c fm33l0xx_spi.c fm33l0xx_svd.c fm33l0xx_u7816.c fm33l0xx_uart.c fm33l0xx_wwdt.c
    ../UserCode/: startup_FM33L0XX.S
software components: CMSIS:CORE 4.3.0
